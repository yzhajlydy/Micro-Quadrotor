# Keil uVision project Quadrotor.uvproj, settings and files
target Quadrotor (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Quadrotor
  c flags: Optim=1
  c include: ..\SRC\HAL;..\SRC\STM32LIB;..\SRC\User
  memory RVCT4: ROM 0x8008000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../SRC/User/: main.c Delay.c stm32f10x_it.c PWM.c Fusion.c Control.c
  group HAL
    ../SRC/HAL/: GPIO.c hal.c NVIC.c RCC.c IIC.c MPU6050.c NRF24L01.c SPI.c TIMx.c DMA.c USART.c
  group FWLIB
    ../SRC/STM32LIB/: core_cm3.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c stm32f10x_dma.c
  group Startup
    ../SRC/Startup/: startup_stm32f10x_md.s
